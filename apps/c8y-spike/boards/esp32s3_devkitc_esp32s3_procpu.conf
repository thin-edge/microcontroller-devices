## tedge-zephyr/tests/unit/testcase.yaml
```yaml
tests:
  tedge.unit:
    platform_allow:
      - native_sim
      - native_sim/native/64
    tags: tedge
```
